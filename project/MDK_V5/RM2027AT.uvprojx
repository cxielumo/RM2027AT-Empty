# Keil uVision project RM2027AT.uvprojx, settings and files
target RM2027AT (6240000::V6.24::ARMCLANG)
  device: -AT32F423CCT7 ArteryTek
  pack: ArteryTek.AT32F423_DFP.2.1.4
  cpu: IRAM(0x20000000,0xC000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: RM2027AT +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: AT32F423CCT7, USE_STDPERIPH_DRIVER, AT_START_F423_V1
  c include: ..\..\libraries\drivers\inc;..\..\libraries\cmsis\cm4\core_support;..\..\libraries\cmsis\cm4\device_support;..\inc;..\..\Algorithm\Inc;..\..\Bsp\Inc;..\..\Components\Inc;..\..\Application\Inc;..\..\ThirdParty\FreeRTOS\MDK-ARM;..\..\ThirdParty\FreeRTOS\Config;..\..\ThirdParty\FreeRTOS\Source\include
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group user
    ../src/: at32f423_int.c at32f423_wk_config.c main.c wk_system.c wk_adc.c wk_can.c wk_tmr.c wk_usart.c wk_dma.c wk_gpio.c
  group firmware
    ../../libraries/drivers/src/: at32f423_crm.c at32f423_tmr.c at32f423_gpio.c at32f423_usart.c at32f423_pwc.c at32f423_adc.c at32f423_dma.c at32f423_debug.c at32f423_flash.c at32f423_exint.c at32f423_misc.c at32f423_can.c
  group cmsis
    ../../libraries/cmsis/cm4/device_support/: system_at32f423.c
    ./: startup_at32f423.s
  group ThirdParty/FreeRTOS
    ../../ThirdParty/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../../ThirdParty/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../../ThirdParty/FreeRTOS/MDK-ARM/: port.c FreeRTOSConfig.h portmacro.h
  group Algorithm
    ../../Algorithm/Inc/: math_utils.h pid.h ramp.h ringBuffer.h
    ../../Algorithm/Src/: pid.c ramp.c ringBuffer.c
  group Bsp
    ../../Bsp/Inc/: adc.h bsp.h can.h led.h os.h pwm.h uart.h
    ../../Bsp/Src/: adc.c bsp.c can.c led.c os.c pwm.c uart.c
  group Components
    ../../Components/Inc/: dbus.h motor.h daemon.h motor_dji.h motor_tt.h servo.h
    ../../Components/Src/: dbus.c motor.c daemon.c motor_dji.c motor_tt.c servo.c
  group Application
    ../../Application/Src/: robot_main.c
